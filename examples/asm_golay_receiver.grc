options:
  parameters:
    author: Diego Hurtado de Mendoza
    generate_options: qt_gui
    id: asm_golay_receiver
    output_language: python
    title: ASM+Golay Receiver
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sps / (2*math.pi) / mod_index
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    comment: |-
      REPLACE ME
      Doppler-corrected IQ source
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Residual CFO correction
    length: '500'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.0045'
    max_dev: '0.2'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate * mod_index
    decim: '1'
    gain: '1'
    samp_rate: sps * baudrate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate
    decim: '1'
    gain: '1'
    samp_rate: sps*baudrate
    type: fir_filter_fff
    width: baudrate/2
    win: firdes.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '128'
    rrate: float(sps*baudrate)/samp_rate
    type: ccf
  states: {}
- name: sattools_asm_golay_decoder_0
  id: sattools_asm_golay_decoder
  parameters:
    asm_bits: '''{:b}''.format(0x930b51de)'
    asm_threshold: '3'
    bitrate: baudrate
    ccsds_randomize: 'True'
    ccsds_rs: 'True'
    crc32c: 'True'
  states: {}
- name: sattools_csp_zmqhub_pub_sink_0
  id: sattools_csp_zmqhub_pub_sink
  parameters:
    pub_endpoint: tcp://address:port
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [blocks_null_source_0, '0', pfb_arb_resampler_xxx_1, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_1, '0']
- [digital_binary_slicer_fb_0, '0', sattools_asm_golay_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', digital_symbol_sync_xx_0, '0']
- [pfb_arb_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [sattools_asm_golay_decoder_0, out, blocks_message_debug_0, print_pdu]
- [sattools_asm_golay_decoder_0, out, sattools_csp_zmqhub_pub_sink_0, pdu]

metadata:
  file_format: 1
